# Keil uVision project NUCLEO_G474RE_FOC.uvprojx, settings and files
target NUCLEO_G474RE_FOC (6210000::V6.21::ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(160000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: NUCLEO_G474RE_FOC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c define: GL30_FOC_USE_CORDIC,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G474xx
  c misc: -Wno-invalid-utf8 -Wno-unsafe-buffer-usage -Wno-padded -Wno-extra-semi-stmt -Wno-missing-noreturn -Wno-declaration-after-statement
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../../../control;../../../config;../../../protocol;../../../drivers;../../../haptics
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_ll_rcc.c stm32g4xx_ll_pwr.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c stm32g4xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Application/GL30_Bench
    ../Core/Src/: bench_app.c bench_cordic.c bench_hw.c bench_safety.c bench_haptics.c
    ../../../control/: foc.c
    ../../../haptics/: haptics.c
    ../../../drivers/: as5048a.c drv8316_spi.c
software components: CMSIS:CORE 4.3.0
