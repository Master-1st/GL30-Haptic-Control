# Keil uVision project GL30_AMOLED_V7.uvprojx, settings and files
target GL30_AMOLED_V7 (6210000::V6.21::ARMCLANG)
  device: STM32G474CETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: GL30_AMOLED_V7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,GL30_BUILD_ONLY=0,HSE_VALUE=24000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G474xx
  c misc: -Wno-invalid-utf8 -Wno-unsafe-buffer-usage -Wno-padded -Wno-extra-semi-stmt -Wno-declaration-after-statement -Wno-missing-noreturn
  c include: ../Core/Inc;../../../app;../../../config;../../../drivers;../../../control;../../../haptics;../../../trace;../../../protocol;../../../safety;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c
  group Application/GL30
    ../../../app/: gl30_app.c
    ../../../control/: foc.c
    ../../../haptics/: haptics.c
    ../../../protocol/: v6_protocol.c
    ../../../safety/: safety_supervisor.c
    ../../../trace/: timebase.c trace_buffer.c
    ../../../drivers/: drv8316.c drv8316_spi.c factory_encoder_pending.c ll_i2c_bus.c ina228.c veml7700.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_ll_rcc.c stm32g4xx_ll_pwr.c stm32g4xx_ll_i2c.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c stm32g4xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
